# Repository amorwilliams/Rools

File README.md:

# Rools

10HP+2HP 可选扩展 Eurorack 多功能可视化 DSP 模块。Daisy Seed + 1.77" 横屏 IPS，单 App 运行模式。

## 文档索引

| 文档 | 说明 |
|------|------|
| [docs/00-overview.md](docs/00-overview.md) | 项目概述 |
| [docs/01-product-spec.md](docs/01-product-spec.md) | 产品规格 |
| [docs/02-panel-layout.md](docs/02-panel-layout.md) | 面板布局 |
| [docs/03-io-spec.md](docs/03-io-spec.md) | I/O 定义 |
| [docs/04-hardware-architecture.md](docs/04-hardware-architecture.md) | 硬件架构 |
| [docs/05-software-architecture.md](docs/05-software-architecture.md) | 软件架构 |
| [docs/06-ui-ux.md](docs/06-ui-ux.md) | 交互规范 |
| [docs/07-roadmap.md](docs/07-roadmap.md) | 开发里程碑 |
| [docs/08-app-switching.md](docs/08-app-switching.md) | App 丝滑切换 |
| [docs/decisions/](docs/decisions/) | ADR 决策记录（含电源/显示/机械） |
| [docs/references/modules-comparison.md](docs/references/modules-comparison.md) | 参考模块对比 |

## 快速开始

```bash
git clone --recursive <repo>
./build.sh          # 编译
./build.sh flash    # 刷机（Seed DFU 模式）
```

详见 [firmware/README.md](firmware/README.md)。

## 依赖版本（git submodule，固定 tag）

| 库 | Tag | Commit |
|----|-----|--------|
| [libDaisy](https://github.com/electro-smith/libDaisy) | **v8.1.0** | `9498417` |
| [DaisySP](https://github.com/electro-smith/DaisySP) | **V1.0.0** | `a0494a3` |

克隆务必带 submodule：`git clone --recursive`。升级依赖时在 `lib/` 内 checkout 新 tag，编译验证后 commit 父仓库的 submodule 指针。

## 目录结构

```
Rools/
├── lib/            # libDaisy / DaisySP submodule
├── docs/           # 设计文档
├── hardware/       # 面板规格、BOM（KiCad 后续）
├── firmware/       # libDaisy 固件
└── build.sh        # 编译脚本
```

## 参考

- [Daisy Seed](https://daisy.audio/hardware/Seed/)
- [O_C 4.1 O.R.N.8](https://modulargrid.net/e/tunefish-modular-ornament-crime-o-c-t4-1-o-r-n-8)

## KiCad design hardware/kicad/rools-core/rools-core.kicad_pcb

File hardware/README.md:

# hardware/

## 子目录

| 路径 | 内容 |
|------|------|
| [kicad/rools-core/](kicad/rools-core/) | **M2** KiCad 工程（10HP Core） |
| [panel/rools-core-10hp-spec.md](panel/rools-core-10hp-spec.md) | 10HP 面板开孔/丝印 |
| [panel/rools-exp-2hp-spec.md](panel/rools-exp-2hp-spec.md) | 2HP Exp 面板 |
| [bom/bom-draft.md](bom/bom-draft.md) | 初步 BOM |

## KiCad

打开 `hardware/kicad/rools-core/rools-core.kicad_pro`（KiCad 10.x）。

层次：`Power` / `Seed` / `Audio` / `CV` / `UI` — 不含 Exp（USB/MIDI）。

音频/电源对照 Daisy Patch Rev8，见 [kicad/rools-core/docs/patch-reference.md](kicad/rools-core/docs/patch-reference.md)。

Parts:
J2: EXP_BUS; PinHeader_2x06_P2.54mm_Vertical
J7: J_TOP_MAIN; PinSocket_2x08_P2.54mm_Vertical_SMD
J_BM_L1: Conn_01x10_Pin; PinSocket_1x10_P2.54mm_Vertical
J_BM_R1: Conn_01x10_Pin; PinSocket_1x10_P2.54mm_Vertical
U_Daisy1: ES_DAISY_SEED; Electrosmith_Daisy_Seed

Connections:
+3V3_A: J2.12, J_BM_L1.1, J_BM_R1.1, U_Daisy1.21 (+3V3_A); also elsewhere on the board
+3V3_D: J2.2, J7.1, U_Daisy1.38 (+3V3_D); also elsewhere on the board
+5V: J2.1, U_Daisy1.39 (V_IN); also elsewhere on the board
AUDIO_IN_L: U_Daisy1.16 (AUDIO_IN_L); also elsewhere on the board
AUDIO_IN_R: U_Daisy1.17 (AUDIO_IN_R); also elsewhere on the board
AUDIO_OUT_L: U_Daisy1.18 (AUDIO_OUT_L); also elsewhere on the board
AUDIO_OUT_R: U_Daisy1.19 (AUDIO_OUT_R); also elsewhere on the board
BTN_CENTER: J7.15, U_Daisy1.5 (GPIO4(SDMMC1_D0)); also elsewhere on the board
CV1_ADC: U_Daisy1.22 (GPIO15(ADC0)); also elsewhere on the board
CV2_ADC: U_Daisy1.23 (GPIO16(ADC1)); also elsewhere on the board
CV3_ADC: U_Daisy1.24 (GPIO17(ADC2)); also elsewhere on the board
CV4_ADC: U_Daisy1.25 (GPIO18(ADC3)); also elsewhere on the board
DAC_CS: U_Daisy1.33 (GPIO26(SAI2_SD_A)); also elsewhere on the board
DAC_LDAC: U_Daisy1.34 (GPIO27(SAI2_FS_B)); also elsewhere on the board
ENC_A_A: J7.4, U_Daisy1.2 (GPIO1(SDMMC1_D3)); also elsewhere on the board
ENC_A_B: J7.6, U_Daisy1.3 (GPIO2(SDMMC1_D2)); also elsewhere on the board
ENC_A_SW: J7.8, U_Daisy1.4 (GPIO3(SDMMC1_D1)); also elsewhere on the board
ENC_B_A: J7.14, U_Daisy1.30 (GPIO23(ADC8/DAC1)); also elsewhere on the board
ENC_B_B: J7.12, U_Daisy1.31 (GPIO24(ADC9)); also elsewhere on the board
ENC_B_SW: J7.10, U_Daisy1.32 (GPIO25(ADC10)); also elsewhere on the board
EXP_GPIO0: J2.10, U_Daisy1.1 (GPIO0(USB_HS_ID))
EXTI_PWR: U_Daisy1.35 (GPIO28(ADC11)); also elsewhere on the board
GND: J2.3, J2.11, J7.2, J7.16, J_BM_L1.10, J_BM_R1.10, U_Daisy1.20 (AGND), U_Daisy1.40 (GND); also elsewhere on the board
I2C_SCL: J2.8, U_Daisy1.12 (GPIO11(I2C1_SCL))
I2C_SDA: J2.9, U_Daisy1.13 (GPIO12(I2C1_SDA))
IN_L_NORM: J_BM_L1.8; also elsewhere on the board
J_AUDIO_IN_R: J_BM_L1.9; also elsewhere on the board
J_AUDIO_OUT_L: J_BM_R1.9; also elsewhere on the board
J_AUDIO_OUT_R: J_BM_R1.8; also elsewhere on the board
J_CV_IN_1: J_BM_R1.5; also elsewhere on the board
J_CV_IN_2: J_BM_R1.4; also elsewhere on the board
J_CV_IN_3: J_BM_R1.3; also elsewhere on the board
J_CV_IN_4: J_BM_R1.2; also elsewhere on the board
J_CV_OUT_1: J_BM_L1.7; also elsewhere on the board
J_CV_OUT_2: J_BM_L1.6; also elsewhere on the board
J_CV_OUT_3: J_BM_R1.6; also elsewhere on the board
J_CV_OUT_4: J_BM_R1.7; also elsewhere on the board
KNOB1_ADC: J_BM_L1.5, U_Daisy1.26 (GPIO19(ADC4)); also elsewhere on the board
KNOB2_ADC: J_BM_L1.4, U_Daisy1.27 (GPIO20(ADC5)); also elsewhere on the board
KNOB3_ADC: J_BM_L1.3, U_Daisy1.28 (GPIO21(ADC6)); also elsewhere on the board
KNOB4_ADC: J_BM_L1.2, U_Daisy1.29 (GPIO22(ADC7/DAC2)); also elsewhere on the board
LCD_BLK: J7.3, U_Daisy1.6 (GPIO5(SDMMC1_CMD)); also elsewhere on the board
LCD_CS: J7.7, U_Daisy1.8 (GPIO7(SPI1_NSS)); also elsewhere on the board
LCD_DC: J7.11, U_Daisy1.10 (GPIO9(SPI1_MISO)); also elsewhere on the board
LCD_RST: J7.5, U_Daisy1.7 (GPIO6(SDMMC1_CK)); also elsewhere on the board
MIDI_RX: J2.7, U_Daisy1.15 (GPIO14(USART1_RX))
MIDI_TX: J2.5, U_Daisy1.14 (GPIO13(USART1_TX))
SPI1_MOSI: J7.13, U_Daisy1.11 (GPIO10(SPI1_MOSI)); also elsewhere on the board
SPI1_SCK: J7.9, U_Daisy1.9 (GPIO8(SPI1_SCK)); also elsewhere on the board
USB_D+: J2.4, U_Daisy1.37 (GPIO30(USB_HS_D+))
USB_D-: J2.6, U_Daisy1.36 (GPIO29(USB_HS_D_-))

Parts:
C1, C4, C5, C6, C7, C8, C11: 10uF; C_0603_1608Metric; LCSC C96446
C2, C3, C9, C38: 100nF; C_0603_1608Metric; LCSC C14663
C10: 22uF; C_0805_2012Metric; LCSC C45783
C36: 470uF/25V; CP_Radial_D8.0mm_P3.50mm; LCSC C43839
D1, D2, D3: SS34; D_SMA; LCSC C8678
FB1, FB2: FerriteBead; L_0603_1608Metric; LCSC C1015
J1: EURO_PWR; IDC-Header_2x05_P2.54mm_Vertical
L1: 4.7uH; L_Taiyo-Yuden_NR-40xx; LCSC C167208
R1: 330K; R_0603_1608Metric; LCSC C23137
R2: 100K; R_0603_1608Metric; LCSC C25803
R3, R64, R65: 10K; R_0603_1608Metric; LCSC C25804
R4: 73.2K; R_0603_1608Metric; LCSC C14890
R43: 22K; R_0603_1608Metric; LCSC C23162
U1: AP2112K-3.3; SOT-23-5; LCSC C51118
U2: TPS54302; TSOT-23-6; LCSC C311903
U10: LM393; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C7955

Connections:
+3V3_D: R65.2, U10.2 (-), U10.6 (-); also elsewhere on the board
+3V3_DAC: C3.1, C6.1, U1.5 (VOUT); also elsewhere on the board
+5V: C1.1, C2.1, C10.1, L1.2, R4.2, U1.1 (VIN), U1.3 (EN); also elsewhere on the board
+12V: C4.1, C7.1, D1.1 (K), D3.2 (A), R43.1; also elsewhere on the board
+12V_SAFE: C11.1, C36.1, C38.2, D3.1 (K), R1.1, U2.3 (VIN), U10.8 (V+)
-12V: C5.2, C8.2, D2.2 (A); also elsewhere on the board
/Power/+12V_IN: FB1.1, J1.9, J1.10
/Power/-12V_IN: FB2.1, J1.1, J1.2
EXTI_PWR: R65.1, U10.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.1, C10.2, C11.2, C36.2, C38.1, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, R2.2, R3.2, R64.2, U1.2 (GND), U2.1 (GND), U10.4 (V-), U10.5 (+); also elsewhere on the board
unnamed: D1.2 (A), FB1.2
unnamed: D2.1 (K), FB2.2
unnamed: C9.1, U2.6 (BOOT)
unnamed: R1.2, R2.1, U2.5 (EN)
unnamed: R3.1, R4.1, U2.4 (FB)
unnamed: C9.2, L1.1, U2.2 (SW)
unnamed: R43.2, R64.1, U10.3 (+)

Notes on the sheet:
P1→FB2→D1: Patch Rev8 反接保护
U1 Buck +12V→+5V (ADR-011)
U1 FB: R1=73.2k R2=10k → 5.0V (Vref=596mV); EN R3/R4=330k/100k

Parts:
C12, C13, C18, C19, C33, C34, C35: 100nF; C_0603_1608Metric; LCSC C14663
C14, C15, C16, C17: 10nF; C_0603_1608Metric; LCSC C1710
J_CV_IN_1, J_CV_IN_2, J_CV_IN_3, J_CV_IN_4: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J_CV_OUT_1, J_CV_OUT_2, J_CV_OUT_3, J_CV_OUT_4: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
R7, R9, R11, R13: 15K; R_0603_1608Metric; Tolerance 0.1%; LCSC C326733
R8, R10, R12, R14, R15, R16, R17, R18: 120K; R_0603_1608Metric; Tolerance 0.1%; LCSC C136959
R19, R20, R21, R22: 1K; R_0603_1608Metric; LCSC C21190
R23, R24, R25, R26, R27, R28, R29, R30: 200K; R_0603_1608Metric; LCSC C728585
R31, R32, R33, R34: 33K; R_0603_1608Metric; LCSC C705768
R35: 2K; R_0603_1608Metric; LCSC C21194
RV1, RV2, RV3, RV4: Knob; RK09L_3pin_noMP
U4: OPA4171; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C46269
U5: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C7378
U6: LM4040DBZ-10; SOT-23; LCSC C201738
U9: DAC8565; TSSOP-16_4.4x5mm_P0.65mm; LCSC C69596

Connections:
+3V3_A: C18.1, RV1.1, RV2.1, RV3.1, RV4.1, U5.4 (V+); also elsewhere on the board
+3V3_D: C35.1, U9.12 (IOVDD), U9.13 (~RST), U9.14 (RSTSEL); also elsewhere on the board
+3V3_DAC: C34.1, U9.4 (AVDD); also elsewhere on the board
+12V: C12.2, U4.4 (V+); also elsewhere on the board
-10V_REF: C19.1, R8.1, R10.1, R12.1, R14.1, R23.1, R25.1, R27.1, R29.1, R35.1, U6.2 (A)
-12V: C13.1, R35.2, U4.11 (V-); also elsewhere on the board
CV1_ADC: C14.2, R31.2, U5.1; also elsewhere on the board
CV2_ADC: C15.2, R32.2, U5.7; also elsewhere on the board
CV3_ADC: C17.2, R34.2, U5.14; also elsewhere on the board
CV4_ADC: C16.2, R33.2, U5.8; also elsewhere on the board
DAC_A: R7.1, U9.8 (VOUTD)
DAC_B: R9.1, U9.7 (VOUTC)
DAC_C: R11.1, U9.2 (VOUTB)
DAC_CS: U9.9 (~SYNC); also elsewhere on the board
DAC_D: R13.1, U9.1 (VOUTA)
DAC_LDAC: U9.16 (LDAC); also elsewhere on the board
GND: C12.1, C13.2, C18.2, C19.2, C33.2, C34.2, C35.2, J_CV_IN_1.T, J_CV_IN_1.TN, J_CV_IN_2.T, J_CV_IN_2.TN, J_CV_IN_3.T, J_CV_IN_3.TN, J_CV_IN_4.T, J_CV_IN_4.TN, J_CV_OUT_1.TN, J_CV_OUT_2.TN, J_CV_OUT_3.TN, J_CV_OUT_4.TN, RV1.3, RV2.3, RV3.3, RV4.3, U4.3 (+), U4.5 (+), U4.10 (+), U4.12 (+), U5.3 (+), U5.5 (+), U5.10 (+), U5.11 (V-), U5.12 (+), U6.1 (K), U9.5 (VREFL), U9.6 (GND), U9.15 (~ENABLE); also elsewhere on the board
J_CV_IN_1: J_CV_IN_1.S, R24.1; also elsewhere on the board
J_CV_IN_2: J_CV_IN_2.S, R26.1; also elsewhere on the board
J_CV_IN_3: J_CV_IN_3.S, R28.1; also elsewhere on the board
J_CV_IN_4: J_CV_IN_4.S, R30.1; also elsewhere on the board
J_CV_OUT_1: J_CV_OUT_1.S, R19.2; also elsewhere on the board
J_CV_OUT_2: J_CV_OUT_2.S, R20.2; also elsewhere on the board
J_CV_OUT_3: J_CV_OUT_3.S, R21.2; also elsewhere on the board
J_CV_OUT_4: J_CV_OUT_4.S, R22.2; also elsewhere on the board
KNOB1_ADC: RV1.2; also elsewhere on the board
KNOB2_ADC: RV2.2; also elsewhere on the board
KNOB3_ADC: RV3.2; also elsewhere on the board
KNOB4_ADC: RV4.2; also elsewhere on the board
unnamed: R15.2, R19.1, U4.1
unnamed: R16.2, R20.1, U4.7
unnamed: R17.2, R21.1, U4.8
unnamed: R18.2, R22.1, U4.14
unnamed: R7.2, R8.2, R15.1, U4.2 (-)
unnamed: R9.2, R10.2, R16.1, U4.6 (-)
unnamed: R11.2, R12.2, R17.1, U4.9 (-)
unnamed: R13.2, R14.2, R18.1, U4.13 (-)
unnamed: C14.1, R23.2, R24.2, R31.1, U5.2 (-)
unnamed: C15.1, R25.2, R26.2, R32.1, U5.6 (-)
unnamed: C16.1, R27.2, R28.2, R33.1, U5.9 (-)
unnamed: C17.1, R29.2, R30.2, R34.1, U5.13 (-)
unnamed: C33.1, U9.3 (VREFH/VREFOUT)
SPI1_MOSI: U9.11 (DIN); also elsewhere on the board
SPI1_SCK: U9.10 (SCLK); also elsewhere on the board

Notes on the sheet:
J_CV_OUT_1 IN: 0V - 2.5V OUT: +10V to -10V

Parts:
C21, C23, C27, C28, C29, C30: 47pF; C_0603_1608Metric; LCSC C1653
C22, C24: 560pF; C_0603_1608Metric; LCSC C1680
C25, C26, C31, C32: 100nF; C_0603_1608Metric; LCSC C14663
J_AI_L1: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J_AI_R1: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J_AO_L1: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J_AO_R1: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
R44, R45, R46, R49, R50, R51, R56, R57, R58, R59, R60, R61: 100K; R_0603_1608Metric; LCSC C25803
R47, R52, R54, R55: 10K; R_0603_1608Metric; LCSC C25804
R48, R53, R62, R63: 1K; R_0603_1608Metric; LCSC C21190
U7, U8: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6964

Connections:
+12V: C25.2, C31.2, U7.4 (V+), U8.4 (V+); also elsewhere on the board
-12V: C26.1, C32.1, U7.11 (V-), U8.11 (V-); also elsewhere on the board
AUDIO_IN_L: R48.2; also elsewhere on the board
AUDIO_IN_R: R53.2; also elsewhere on the board
AUDIO_OUT_L: R54.1; also elsewhere on the board
AUDIO_OUT_R: R55.1; also elsewhere on the board
GND: C25.1, C26.2, C31.1, C32.2, J_AI_L1.T, J_AI_L1.TN, J_AI_R1.TN, J_AO_L1.T, J_AO_L1.TN, J_AO_R1.T, J_AO_R1.TN, U7.3 (+), U7.5 (+), U7.10 (+), U7.12 (+), U8.3 (+), U8.5 (+), U8.10 (+), U8.12 (+); also elsewhere on the board
IN_L_NORM: J_AI_L1.S, J_AI_R1.T, R44.1; also elsewhere on the board
J_AUDIO_IN_R: J_AI_R1.S, R49.1; also elsewhere on the board
J_AUDIO_OUT_L: J_AO_L1.S, R62.2; also elsewhere on the board
J_AUDIO_OUT_R: J_AO_R1.S, R63.2; also elsewhere on the board
unnamed: C21.2, R45.2, R46.1, U7.1
unnamed: C22.2, R47.2, R48.1, U7.14
unnamed: C23.2, R50.2, R51.1, U7.7
unnamed: C24.2, R52.2, R53.1, U7.8
unnamed: C27.2, R56.2, R58.1, U8.1
unnamed: C28.2, R57.2, R59.1, U8.7
unnamed: C29.2, R60.2, R62.1, U8.14
unnamed: C30.2, R61.2, R63.1, U8.8
unnamed: C21.1, R44.2, R45.1, U7.2 (-)
unnamed: C23.1, R49.2, R50.1, U7.6 (-)
unnamed: C24.1, R51.2, R52.1, U7.9 (-)
unnamed: C22.1, R46.2, R47.1, U7.13 (-)
unnamed: C27.1, R54.2, R56.1, U8.2 (-)
unnamed: C28.1, R55.2, R57.1, U8.6 (-)
unnamed: C30.1, R59.2, R61.1, U8.9 (-)
unnamed: C29.1, R58.2, R60.1, U8.13 (-)

Parts:
C20: 100nF; C_0603_1608Metric; LCSC C14663
J4: ST7789; Display_1.54in_240x240
J6: J_TOP_UI; PinHeader_2x08_P2.54mm_Vertical
J_BU_L1: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
J_BU_R1: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
R36, R37, R38, R39, R40, R41, R42: 10K; R_0603_1608Metric; LCSC C25804
SW1, SW2: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW3: SW_Push; SW_PUSH_6mm

Connections:
+3V3_A: J_BU_L1.1, J_BU_R1.1; also elsewhere on the board
+3V3_D: C20.1, J4.2 (VCC), J6.1, R36.1, R37.2, R38.1, R39.1, R40.2, R41.1, R42.1; also elsewhere on the board
BTN_CENTER: J6.15, R42.2, SW3.1; also elsewhere on the board
ENC_A_A: J6.4, R36.2, SW1.A; also elsewhere on the board
ENC_A_B: J6.6, R37.1, SW1.B; also elsewhere on the board
ENC_A_SW: J6.8, R38.2, SW1.S1; also elsewhere on the board
ENC_B_A: J6.14, R39.2, SW2.A; also elsewhere on the board
ENC_B_B: J6.12, R40.1, SW2.B; also elsewhere on the board
ENC_B_SW: J6.10, R41.2, SW2.S1; also elsewhere on the board
GND: C20.2, J4.1 (GND), J6.2, J6.16, J_BU_L1.10, J_BU_R1.10, SW1.C, SW1.S2, SW2.C, SW2.S2, SW3.2; also elsewhere on the board
IN_L_NORM: J_BU_L1.8; also elsewhere on the board
J_AUDIO_IN_R: J_BU_L1.9; also elsewhere on the board
J_AUDIO_OUT_L: J_BU_R1.9; also elsewhere on the board
J_AUDIO_OUT_R: J_BU_R1.8; also elsewhere on the board
J_CV_IN_1: J_BU_R1.5; also elsewhere on the board
J_CV_IN_2: J_BU_R1.4; also elsewhere on the board
J_CV_IN_3: J_BU_R1.3; also elsewhere on the board
J_CV_IN_4: J_BU_R1.2; also elsewhere on the board
J_CV_OUT_1: J_BU_L1.7; also elsewhere on the board
J_CV_OUT_2: J_BU_L1.6; also elsewhere on the board
J_CV_OUT_3: J_BU_R1.6; also elsewhere on the board
J_CV_OUT_4: J_BU_R1.7; also elsewhere on the board
KNOB1_ADC: J_BU_L1.5; also elsewhere on the board
KNOB2_ADC: J_BU_L1.4; also elsewhere on the board
KNOB3_ADC: J_BU_L1.3; also elsewhere on the board
KNOB4_ADC: J_BU_L1.2; also elsewhere on the board
LCD_BLK: J4.8 (BLK), J6.3; also elsewhere on the board
LCD_CS: J4.7 (CS), J6.7; also elsewhere on the board
LCD_DC: J4.6 (DC), J6.11; also elsewhere on the board
LCD_RST: J4.5 (RST), J6.5; also elsewhere on the board
SPI1_MOSI: J4.4 (MOSI), J6.13; also elsewhere on the board
SPI1_SCK: J4.3 (SCK), J6.9; also elsewhere on the board

Notes on the sheet:
J1: GND VCC SCK MOSI RST DC CS BLK

Board: 4 copper layers, 102.0 x 108.0 mm, 144 parts (45 on the bottom side), 98 nets.

## Code that names these connections

File firmware/src/board/pins.h:

#pragma once

#include "daisy_seed.h"

// Rools Core Seed map — 2026-06 定稿（见 docs/04-hardware-architecture.md）

namespace rools {
namespace pins {

using Pin = daisy::Pin;

// D0 / pin 1 — EXP_GPIO0（USB_HS_ID，P2 pin 15）

// Enc A — D1–D3, Seed pins 2–4
constexpr Pin kEncA_A  = daisy::seed::D1;
constexpr Pin kEncA_B  = daisy::seed::D2;
constexpr Pin kEncA_Sw = daisy::seed::D3;

// Btn + ST7735 SPI — D4–D10, Seed pins 5–11
constexpr Pin kBtnCenter = daisy::seed::D4;
constexpr Pin kLcdBlk    = daisy::seed::D5;
constexpr Pin kLcdRst    = daisy::seed::D6;
constexpr Pin kLcdCs     = daisy::seed::D7;
constexpr Pin kLcdSck    = daisy::seed::D8;  // SPI1_SCK — 亦接 DAC8565
constexpr Pin kLcdDc     = daisy::seed::D9;
constexpr Pin kLcdMosi   = daisy::seed::D10; // SPI1_MOSI — 亦接 DAC8565

// D11–D12 / pin 12–13 — I2C1 → P2 EXP_BUS（SCL/SDA）

// Exp MIDI — D13–D14, Seed pins 14–15, USART1
constexpr Pin kMidiTx = daisy::seed::D13;
constexpr Pin kMidiRx = daisy::seed::D14;

// DAC8565 CV Out — D26–D27, Seed pins 33–34
constexpr Pin kDacCs   = daisy::seed::D26; // DAC_CS / SYNC
constexpr Pin kDacLdac = daisy::seed::D27; // DAC_LDAC

// CV in — D15–D18, Seed pins 22–25, ADC0–3
constexpr Pin kCv1Adc = daisy::seed::D15;
constexpr Pin kCv2Adc = daisy::seed::D16;
constexpr Pin kCv3Adc = daisy::seed::D17;
constexpr Pin kCv4Adc = daisy::seed::D18;

// Knob — D19–D22, Seed pins 26–29, ADC4–7
constexpr Pin kKnob1Adc = daisy::seed::D19;
constexpr Pin kKnob2Adc = daisy::seed::D20;
constexpr Pin kKnob3Adc = daisy::seed::D21;
constexpr Pin kKnob4Adc = daisy::seed::D22;

// Enc B — D23–D25, Seed pins 30–32
constexpr Pin kEncB_A  = daisy::seed::D23;
constexpr Pin kEncB_B  = daisy::seed::D24;
constexpr Pin kEncB_Sw = daisy::seed::D25;

// D28 / pin 35 — net EXTI_PWR（LM393 掉电检测，见 ADR-015）
constexpr Pin kPwrFail = daisy::seed::D28;

} // namespace pins
} // namespace rools

## Commit log (part)

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2026-06-13 inti
2026-06-14 Document firmware framework lifecycle and app registration.
    Clarify App/AppShell thread model, main loop structure, and how to add apps via AppRegistry.
